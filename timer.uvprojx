# Keil uVision project timer.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: timer
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: RCC_STM32.h RCC_STM32.c GPIO.h GPIO.c main.c TIMER.h SPI.h DMA.h SPI.c ADC.c ADC.h Define.h ADC_DMA.c module_actuator.h module_actuator.c Fire_detection.h Fire_detection.c SPI_Protocol.h SPI_Protocol.c NVIC.h NVIC.c
software components: CMSIS:CORE 6.2.0, Device:Startup 2.6.3
